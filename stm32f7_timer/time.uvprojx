# Keil uVision project time.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: time
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
  group lib
    ./: tim.c spi.c tim.h spi.h
software components: CMSIS:CORE 5.2.0, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SPI 1.2.6, Device:STM32Cube HAL:TIM 1.2.6, Device:Startup 1.2.2
